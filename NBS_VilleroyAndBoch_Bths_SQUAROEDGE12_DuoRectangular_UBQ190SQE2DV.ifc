Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-11-27T08:36:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Fri Nov 27 08:36:53 2020* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\{7B43A5C5-F1E6-4A76-8BFB-15D0FC7F5ECD}\ifc* Database version: 5507* Database creation date: Fri Nov 27 08:36:52 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Fri Nov 27 08:36:52 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Fri Nov 27 08:36:52 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDistributionPort, Port_320987
Description: Flow; FlowDirection: SINK

# IfcFlowTerminal: SQUAROEDGE 12_DuoRectangular_1900x900, NBS_VilleroyAndBoch_Bths_SQUAROEDGE12_DuoRectangular_UBQ190SQE2DV:SQUAROEDGE 12_DuoRectangular_1900x900:320987
In: Level 0
Type - PredefinedType: BATH; Classification: Pr_40_20_06_08 (Uniclass2015); Material: NBS_VilleroyAndBoch_Quaryl_WhiteAlpin
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBoch_Baths_SQUAROEDGE12_DuoRectangular_1900x900; ManufacturerName: Villeroy & Boch; ManufacturerURL: https://pro.villeroy-boch.com/en/gb/home.html; NBSCertification: www.nationalbimlibrary.com/cert/ajpoy3q1; NBSDescription: Baths; NBSReference: 45-35-70/311; ProductInformation: https://pro.villeroy-boch.com/en/gr/bathroom-and-wellness/product-detail/m/UBQ190SQE2DV.html?tx_mmpdu_profiportal%5Baction%5D=detail&cHash=9d086e224d79764aa6a049ffb2f7ea3b; Revision: n/a; Uniclass2015Title: Baths; Uniclass2015Code: Pr_40_20_06_08; Uniclass2015Version: Products v1.17; Version: 1
Type - NBS_Data - Accessories: Special whirlpool system; Weight: 50.9 kg
Type - Pset_SanitaryTerminalTypeCommon - Color: White alpin, star white, stone white; NominalDepth: 450 mm; NominalLength: 1900 mm; NominalWidth: 900 mm; Reference: n/a
Type - Pset_SanitaryTerminalTypeBath - HasGrabHandles: no; BathType: Duo; DrainSize: 52 mm
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: BATH
Type - COBie - NominalHeight: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_06_08:Baths; CodePerformance: n/a; Constituents: n/a; Description: Duo rectangular bath; DurationUnit: year; ExpectedLife: n/a; Features: Set of self adhesive adjustable bath feet supplied, extended waste overflow combination, quick and easy to clean, long lasting; Finish: n/a; Grade: n/a; Manufacturer: marketing@villeroy-boch.co.uk; Material: Quaryl; ModelNumber: UBQ190SQE2DV; ModelReference: SQUAROEDGE 12_DuoRectangular_1900x900; Name: Baths_SQUAROEDGE12_DuoRectangular1900x900Quaryl_UBQ190SQE2DV_VilleroyAndBoch; ReplacementCost: n/a; Shape: Rectangular; Size: 1900 x 900 x 450 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
